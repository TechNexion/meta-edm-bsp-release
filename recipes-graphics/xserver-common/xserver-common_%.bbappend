RDEPENDS_${PN}_remove = "xinput-calibrator"
